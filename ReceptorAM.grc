options:
  parameters:
    generate_options: qt_gui
    id: ReceptorAM
    output_language: python
    title: Receptor_AM
  states: {}

blocks:
- name: convert
  id: variable
  parameters:
    value: '125000000'
  states: {}
- name: decimate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Center Frequency
    start: '550'
    step: '10'
    stop: '1700'
    value: '1280'
  states: {}
- name: passband
  id: variable_qtgui_range
  parameters:
    label: Filter kHz
    min_len: '100'
    start: '3'
    step: '1'
    stop: '10'
    value: '6'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    min_len: '100'
    start: '10'
    step: '5'
    stop: '70'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '10000'
    audio_stop: '11000'
    chan_rate: samp_rate/decimate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: passband*1000
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/decimate
    type: fir_filter_ccf
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '200'
    interp: '48'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: decimate
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    corr0: '80'
    freq0: (freq*1000) + convert
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_am_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', analog_am_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
